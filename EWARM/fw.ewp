# IAR project fw.ewp, settings and files
configuration fw (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; USING_INIT_EXPORT
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\GSI\Components\elog; ..\GSI\Device; ..\GSI\Utility; ..\GSI; ..\Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fw.hex
  ILINK.IlinkOutputFile: fw.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Core/Src/: Appsenso_temp.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group GSI/Components
    ../GSI/Components/elog/: elog.c elog_port.c
  group GSI/Device
    ../GSI/Device/: pin.c sensor.c serial.c
  group GSI/Utility
    ../GSI/Utility/: dataqueue.c export.c list.c ringbuffer.c
  group SensorDriver
    ../SensorDriver/: drv_adxl345.c drv_sht21.c drv_th02.c
  group STDrivers/Borad
    ../Drivers/: board.c drv_gpio.c drv_uart.c
  group STDrivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group STDrivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
